# Keil uVision project HOPE-CheroVersion.uvprojx, settings and files
target HOPE-CheroVersion_Debug (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IROM1(0x0,0x80000) IROM2(0x3000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: HOPE-CheroVersion +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: .\common;.\source;.\driver\inc;.\hardware\WS2812;.\hardware\OLED;.\hardware\SW_I2C;.\hardware\BEEPER;.\system\delay;.\system\sys;.\system\usart;.\hardware\Encoder;.\hardware\MultiButton;.\hardware\timer;.\hardware\MPU6500;.\hardware\W25Q128;.\hardware\usb_app;.\midwares\usb;.\midwares\usb\usb_device_lib\device_class\msc;.\midwares\usb\usb_device_lib\device_core;.\hardware\U8G2;.\hardware\Hugo_UI;.\hardware\MALLOC;.\hardware\FileSystem
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f460.s
    ./common/: system_hc32f460.c
  group source
    ./source/: main.c
  group driver
    ./driver/src/: hc32_ll.c hc32_ll_icg.c hc32_ll_utility.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_efm.c hc32_ll_clk.c hc32_ll_gpio.c hc32_ll_fcg.c hc32_ll_aos.c hc32_ll_cmp.c hc32_ll_interrupts.c hc32f460_ll_interrupts_share.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_spi.c
  group hardware
    ./hardware/WS2812/: WS2812.c WS2812.h
    ./hardware/OLED/: OLED.c OLED.h oledfont.h
    ./hardware/SW_I2C/: SW_I2C_OLED.c SW_I2C_OLED.h SW_I2C_SEN.c SW_I2C_SEN.h
    ./hardware/BEEPER/: BEEPER.c BEEPER.h
    ./hardware/Encoder/: Encoder.c Encoder.h
    ./hardware/MultiButton/: multi_button_user.c multi_button_user.h multi_button.c multi_button.h
    ./hardware/timer/: timer.c timer.h
    ./hardware/MPU6500/: MPU6500.c MPU6500.h
    ./hardware/W25Q128/: W25Q128.c W25QXX.h
  group system
    ./system/delay/: delay.c delay.h
    ./system/sys/: sys.h
    ./system/usart/: usart.c usart.h
  group USB
    ./driver/src/: hc32_ll_usb.c
    ./midwares/usb/usb_device_lib/device_core/: usb_dev_core.c usb_dev_ctrleptrans.c usb_dev_driver.c usb_dev_int.c usb_dev_stdreq.c
    ./midwares/usb/usb_device_lib/device_class/msc/: usb_dev_msc_bot.c usb_dev_msc_class.c usb_dev_msc_data.c usb_dev_msc_scsi.c
    ./hardware/usb_app/: usb_bsp.c usb_dev_desc.c usb_dev_user.c usb_dev_msc_msd.c
  group MALLOC
    ./hardware/MALLOC/: malloc.c
  group HugoUI
    ./hardware/Hugo_UI/: Hugo_UI.c HugoUI_BMP.c HugoUI_User.c
    ./hardware/OLED/: OLED_User.c
    ./hardware/FileSystem/: FileSystem.c
  group U8G2
    ./hardware/U8G2/: mui.c mui_u8g2.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_Init.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_a2printer.c u8x8_d_sh1107.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
target HOPE-CheroVersion_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460KETA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: as above
  output: HOPE-CheroVersion +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: .\common;.\source;.\driver\inc;.\hardware\WS2812;.\hardware\OLED;.\hardware\SW_I2C;.\hardware\BEEPER;.\system\delay;.\system\sys;.\system\usart;.\hardware\Encoder;.\hardware\MultiButton;.\hardware\timer;.\hardware\MPU6500;.\hardware\W25Q128;.\midwares\usb;.\midwares\usb\usb_device_lib\device_core;.\midwares\usb\usb_device_lib\device_class\msc;.\hardware\usb_app;.\hardware\U8G2;.\hardware\Hugo_UI;.\hardware\MALLOC;.\hardware\FileSystem
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
