# Keil uVision project iec60730_class_b.uvprojx, settings and files
target iec60730_class_b_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: iec60730_class_b +hex
  AfterMake: ./../../../../../../utils/SRecord/srec_cat ./output/debug/iec60730_class_b.hex -intel -crop 0 0x0007FFDC -fill 0xFF 0x00000 0x0007FFDC -crc32-l-e 0x0007FFDC -o ./output/debug/iec60730_class_b_crc32.hex -intel -obs=16
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: ../source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../source/test_impl_item;../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2;../../../../../../midwares/hc32/iec60730_class_b_stl;../../../../../../midwares/hc32/iec60730_class_b_stl/stl_test_item/inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x03000C00 size 0x3C0
  memory RVCT9: RAM 0x1FFF8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f460.s
    ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group source
    ../source/: main.c runtime_test.c startup_test.c
    ../source/test_impl_item/: test_impl_adc.c test_impl_clk.c test_impl_gpio.c test_impl_interrupt.c test_impl_wdt.c
  group driver
    ../../../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmra.c hc32_ll_usart.c hc32_ll_utility.c
  group ev_hc32f460_lqfp100_v2
    ../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group iec60730_class_b_stl
    ../../../../../../midwares/hc32/iec60730_class_b_stl/: stl_test_runtime.c stl_test_startup.c stl_utility.c
    ../../../../../../midwares/hc32/iec60730_class_b_stl/stl_test_item/src/: stl_sw_crc32.c stl_test_flash.c stl_test_interrupt.c stl_test_ram_runtime.c
    ../../../../../../midwares/hc32/iec60730_class_b_stl/stl_test_item/src/MDK/: stl_test_cpu_runtime.s stl_test_cpu_cm4_startup.s stl_test_full_ram_startup.s stl_test_pc.s
  group Readme
    ../: Readme.txt
target iec60730_class_b_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: as above
  output: iec60730_class_b +hex
  AfterMake: ./../../../../../../utils/SRecord/srec_cat ./output/release/iec60730_class_b.hex -intel -crop 0 0x0007FFDC -fill 0xFF 0x00000 0x0007FFDC -crc32-l-e 0x0007FFDC -o ./output/release/iec60730_class_b_crc32.hex -intel -obs=16
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: ..\source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../source/test_impl_item;../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2;../../../../../../midwares/hc32/iec60730_class_b_stl;../../../../../../midwares/hc32/iec60730_class_b_stl/stl_test_item/inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x03000C00 size 0x3C0
  memory RVCT9: RAM 0x1FFF8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
