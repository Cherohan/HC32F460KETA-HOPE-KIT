# Keil uVision project iap_app.uvprojx, settings and files
target iap_app_Debug (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: iap_app +hex
  AfterMake: fromelf  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: ../source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2;../../../../../../midwares/hc32/iap/modem;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x03000C00 size 0x3C0
  memory RVCT9: RAM 0x1FFF8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f460.s
    ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group source
    ../source/: main.c com.c flash.c
  group driver
    ../../../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_crc.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_utility.c
  group ev_hc32f460_lqfp100_v2
    ../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group iap
    ../../../../../../midwares/hc32/iap/modem/: modem.c
  group Readme
    ../: Readme.txt
target iap_app_Release (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: as above
  output: iap_app +hex
  AfterMake: fromelf  --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: ..\source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2;../../../../../../midwares/hc32/iap/modem;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x03000C00 size 0x3C0
  memory RVCT9: RAM 0x1FFF8000 size 0x2F000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
