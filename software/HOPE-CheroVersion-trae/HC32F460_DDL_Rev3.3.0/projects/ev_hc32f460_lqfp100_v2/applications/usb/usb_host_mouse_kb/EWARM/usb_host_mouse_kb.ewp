# IAR project usb_host_mouse_kb.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default    None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ../source; ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include; ../../../../../../drivers/cmsis/Include; ../../../../../../drivers/hc32_ll_driver/inc; ../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2; ../../../../../../midwares/hc32/usb; ../../../../../../midwares/hc32/usb/usb_host_lib/host_core; ../../../../../../midwares/hc32/usb/usb_host_lib/host_class/hid
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_host_mouse_kb.hex
  ILINK.IlinkOutputFile: usb_host_mouse_kb.out
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F460_512K_= 1
  ILINK.IlinkIcfFile: config/linker/HC32F460.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F460; USE_DDL_DRIVER
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group cmsis
    ../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
    ./: startup_hc32f460.s
  group driver
    ../../../../../../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_keyscan.c hc32_ll_pwc.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_usb.c hc32_ll_utility.c
  group bsp/ev_hc32f460_lqfp100_v2
    ../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2/: ev_hc32f460_lqfp100_v2.c
  group midwares/usb/usb_host_lib/host_core
    ../../../../../../midwares/hc32/usb/usb_host_lib/host_core/: usb_host_cfgch.c usb_host_core.c usb_host_ctrltrans.c usb_host_driver.c usb_host_int.c usb_host_stdreq.c
  group midwares/usb/usb_host_lib/host_class/hid
    ../../../../../../midwares/hc32/usb/usb_host_lib/host_class/hid/: usb_host_hid_class.c usb_host_hid_keyboardapp.c usb_host_hid_mouseapp.c
  group source
    ../source/: main.c usb_bsp.c usb_host_user.c usb_host_user_print.c
